# Keil uVision project project.uvprojx, settings and files
target STM32f407 (6120000::V6.12::.\ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: App;Drivers;Libs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./App/: main.cpp
  group Drivers
    ./Drivers/: mcal_reg.h uartBSP.cpp uartBSP.h led.cpp led.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
